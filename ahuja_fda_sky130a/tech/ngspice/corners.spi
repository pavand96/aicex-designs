.lib Gt
*Nothing here

.endl

.lib Tt
.lib "../../../tech/ngspice/temperature.spi" Tt

.endl

.lib Tl
.lib "../../../tech/ngspice/temperature.spi" Tl

.endl

.lib Tm
.lib "../../../tech/ngspice/temperature.spi" Tm

.endl

.lib Th
.lib "../../../tech/ngspice/temperature.spi" Th

.endl

.lib Vt
.lib "../../../tech/ngspice/supply.spi" Vt

.endl

.lib Vl
.lib "../../../tech/ngspice/supply.spi" Vl

.endl

.lib Vh
.lib "../../../tech/ngspice/supply.spi" Vh

.endl

.lib Att
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" tt

.endl

.lib Asf
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" sf

.endl

.lib Afs
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" fs

.endl

.lib Aff
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" ff

.endl

.lib Ass
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" ss

.endl

.lib All
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" ll

.endl

.lib Ahh
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" hh

.endl

.lib Ahl
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" hl

.endl

.lib Alh
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" lh

.endl

.lib Amctt
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" tt_mm

.endl

.lib Amcsf
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" sf_mm

.endl

.lib Amcfs
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" fs_mm

.endl

.lib Amcff
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" ff_mm

.endl

.lib Amcss
.lib  "$PDK_ROOT/sky130A/libs.tech/ngspice/sky130.lib.spice" ss_mm

.endl

.lib Kff
.param mc_mm_switch=0
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__ff.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__ff.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__ff.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__ff.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/ff/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__f.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_low__cap_low.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_low__cap_low__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/ff/specialized_cells.spice"

.endl

.lib Kffmm
.param mc_mm_switch=1
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__ff.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__ff.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__ff.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__ff.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/ff/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__f.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_low__cap_low.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_low__cap_low__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/ff/specialized_cells.spice"

.endl

.lib Kfs
.param mc_mm_switch=0
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__fs.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__fs.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__fs.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__fs.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/fs/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/fs/specialized_cells.spice"

.endl

.lib Kfsmm
.param mc_mm_switch=1
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__fs.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__fs.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__fs.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__fs.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/fs/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/fs/specialized_cells.spice"

.endl

.lib Khh
.param mc_mm_switch=0
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_high__cap_high.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_high__cap_high__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/specialized_cells.spice"

.endl

.lib Khhmm
.param mc_mm_switch=1
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_high__cap_high.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_high__cap_high__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/specialized_cells.spice"

.endl

.lib Khl
.param mc_mm_switch=0
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_high__cap_low.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_high__cap_low__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/specialized_cells.spice"

.endl

.lib Khlmm
.param mc_mm_switch=1
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_high__cap_low.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_high__cap_low__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/specialized_cells.spice"

.endl

.lib Klh
.param mc_mm_switch=0
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_low__cap_high.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_low__cap_high__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/specialized_cells.spice"

.endl

.lib Klhmm
.param mc_mm_switch=1
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_low__cap_high.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_low__cap_high__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/specialized_cells.spice"

.endl

.lib Kll
.param mc_mm_switch=0
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_low__cap_low.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_low__cap_low__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/specialized_cells.spice"

.endl

.lib Kllmm
.param mc_mm_switch=1
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_low__cap_low.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_low__cap_low__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/specialized_cells.spice"

.endl

.lib Kmc
.param mc_mm_switch=0
.param mc_pr_switch=1
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/parameters/critical.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/parameters/montecarlo.spice"

.endl

.lib Ksf
.param mc_mm_switch=0
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__sf.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__sf.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__sf.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__sf.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/sf/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/sf/specialized_cells.spice"

.endl

.lib Ksfmm
.param mc_mm_switch=1
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__sf.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__sf.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__sf.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__sf.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/sf/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/sf/specialized_cells.spice"

.endl

.lib Kss
.param mc_mm_switch=0
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__ss.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__ss.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__ss.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__ss.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/ss/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__s.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_high__cap_high.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_high__cap_high__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/ss/specialized_cells.spice"

.endl

.lib Kssmm
.param mc_mm_switch=1
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__ss.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__ss.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__ss.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__ss.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/ss/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__s.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_high__cap_high.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_high__cap_high__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/ss/specialized_cells.spice"

.endl

.lib Ktt
.param mc_mm_switch=0
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/specialized_cells.spice"

.endl

.lib Kttmm
.param mc_mm_switch=1
.param mc_pr_switch=0
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__tt.pm3.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__nfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__tt.corner.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__pfet_01v8_lvt__mismatch.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/nonfet.spice"
.include "$PDK_ROOT/sky130A/libs.ref/sky130_fd_pr/spice/sky130_fd_pr__npn_05v5__t.corner.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/all.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/r+c/res_typical__cap_typical__lin.spice"
.include "$PDK_ROOT/sky130A/libs.tech/ngspice/corners/tt/specialized_cells.spice"

.endl
